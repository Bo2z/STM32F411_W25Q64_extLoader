# Keil uVision project STM32F411_W25Q64_extLoader.uvprojx, settings and files
target STM32F411_W25Q64_extLoader (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32F411_W25Q64_extLoader +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: STM32F411xE,USE_FULL_LL_DRIVER,HSE_VALUE=25000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=1,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,VECT_TAB_SRAM
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: Dev_Inf.c Loader_Src.c stm32_eval_spi_flash.c main.c gpio.c spi.c stm32f4xx_it.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_gpio.c stm32f4xx_ll_spi.c stm32f4xx_ll_dma.c stm32f4xx_ll_rcc.c stm32f4xx_ll_utils.c stm32f4xx_ll_exti.c
target STM32F411_W25Q64_stldr (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: as above
  output: STM32F411_W25Q64_extLoader +hex
  AfterMake: cmd.exe /C copy "!L" "..\@L.stldr"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: as above
  c include: as above
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
  scatter file: .\Target.lin
software components: CMSIS:CORE 4.3.0
